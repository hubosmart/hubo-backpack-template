# Repository hubosmart/hubo-backpack-template

File README.md:

English | [简体中文](./README.zh-CN.md)

# Hubo-Tack 30-pin backpack template

A blank KiCad 10 project for a backpack board that plugs into the Hubo-Tack 30-pin connector.
The outline, mounting holes, header, ID card and 5 V input protection are already done and pass
ERC, DRC and the backpack check — you only add your own circuit.

| Top | Bottom |
|---|---|
|  |  |

The easiest way to use it is through the AI skill in
[hubo-backpack-skill](https://github.com/hubosmart/hubo-backpack-skill), which ships a copy of this
template and walks an agent through the design and checks. The interface rules are in
[hubo-backpack-spec](https://github.com/hubosmart/hubo-backpack-spec).

## What is already on the board

| Block | Parts | Why |
|---|---|---|
| 30-pin header (bottom) | H1 | Position, pad numbers and nets follow the spec; pads 16/19/20/21/22/26 are left open |
| Outline and holes | SCREW1–4 | 83.0 × 40.0 mm, R2 corners, four M2 holes at (±39.5, ±18.0) mm, tied to GND |
| 5 V input protection | D2, U4 (TPS259533 eFuse, ≈2.04 A limit), C1–C5, C12, R2, R3, R7 | The backpack protects itself; eFuse fault (FLT) goes to `ESP_INT` through R7 |
| Protected 5 V for you | R5 (0 Ω), C6–C8, inner layer PWR | `5V_USER` is a full plane on the PWR layer — take power from it anywhere |
| ID card, programmed type | U1 (AT24C02 at I²C 0x57), R11 + TP3 (WP), R14/R15 (100 Ω), C13 | DIY boards must program a descriptor, see below |
| Reuse-area series resistors | R21–R28 (0402, 0 Ω) + TP21–TP28 | One per reuse pad, near the header, as the spec requires |

Reuse pads and their nets:

| Header pad | 7 | 8 | 9 | 10 | 25 | 27 | 28 | 29 |
|---|---|---|---|---|---|---|---|---|
| Series resistor | R21 | R22 | R23 | R24 | R25 | R26 | R27 | R28 |
| Your side (net / test point) | USR_P7 / TP21 | USR_P8 / TP22 | USR_P9 / TP23 | USR_P10 / TP24 | USR_P25 / TP25 | USR_P27 / TP26 | USR_P28 / TP27 | USR_P29 / TP28 |

What each reuse pad means depends on the `form_id` in your ID card. For the definition of every pin and the interface figure, see ["30-pin interface at a glance" on the hubo-backpack-spec front page](https://github.com/hubosmart/hubo-backpack-spec#30-pin-interface-at-a-glance).

## What you may change

- Everything you add on the top side, powered from `5V_USER`, connected to `USR_P*`, `ID_SCL`/`ID_SDA`
  (other I²C devices must avoid 0x50–0x57) and `ESP_INT`.
- C6–C8 values, to suit your load.
- Remove TP21–TP28 if you don't need them. They are only debug test points; their position says nothing about where
  connectors belong.
- Place parts per SPEC-003 2.11–2.14: external connectors (USB-C, HDMI, RJ45, SMA, buttons and the like) on the right
  edge, opposite the header, none on the header side; connectors for cables that stay inside the enclosure (FPC, U.FL)
  on the top edge.

## What you must not change

- Outline, hole positions, header position and its pad nets.
- The ID card address (0x57), the WP pull-up R11 and test point TP3.
- Do not power heavy loads from `3V3` (≤ 50 mA in total); use `5V_USER`, 5 V total ≤ 2 A.

R5 reaches the `5V_USER` plane through two vias. If your load is close to 2 A, add vias next to R5.

## Programming the ID card (required for DIY)

1. Pick a `product_id` from the DIY range `0xF000`–`0xFFFE` (no need to ask anyone).
2. Generate the 16-byte image with the skill's tool:
   `python idcard_image.py --form-id 0 --product-id 0xF001 --hw-ver 0x10 -o idcard.bin`
3. Pull TP3 (WP) low and write the image to the AT24C02 at I²C address 0x57, offset 0x00, with any I²C
   EEPROM programmer.

## Checks

- ERC 0, DRC 0 (all severities, with schematic parity), backpack check: no FAIL.
- Checks switched off in the project settings (cosmetic or not applicable to this template):
  ERC — global label only appears once, four connection points joined, SPICE model issue,
  footprint filter mismatch; DRC — footprint has no courtyard, track endpoint not centered on via,
  tuning profile track geometries, footprint does not match symbol filters, footprint type does not
  match pads. Turn them back on if your design needs them.
- Passing the checks does not mean the board is ready to order. **The last check must be a human.**

## License

CERN-OHL-P v2, see [LICENSE](LICENSE). The footprints and symbols in `kicad/lib/` are part of this
project. All 3D models are referenced from the KiCad libraries (`${KICAD10_3DMODEL_DIR}`) and are not
distributed here; they keep their own license (CC-BY-SA 4.0 with the KiCad library exception).

## KiCad design kicad/hubo-backpack-template.kicad_pcb

Parts:
C1, C3, C12, C13: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
C2, C4, C7: 10uF; C_0603_1608Metric; MPN CL10A106KP8NNNC; LCSC C19702
C5: 3.3nF; C_0402_1005Metric; MPN 0402B332K500NT; LCSC C1536
C6: 47uF; C_1206_3216Metric; MPN CL31A476MQHNNNE; LCSC C68361
C8: 100uF; C_1206_3216Metric; MPN CL31A107MQHNNNE; LCSC C15008
D2: SMF5.0A; D_SOD-123F; MPN SMF5.0A; LCSC C19077497
H1: HUBO_TACK_30PIN; HDR-SMD_30P-P2.00-V-M-R2-C15-LS6.5; MPN 20PZ-2x15P-SMT-H2.0-PA3.8; LCSC C54930122
R2, R11: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R3, R7: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R5: 0R; R_1206_3216Metric; MPN 1206W4F0000T5E; LCSC C17888
R14, R15: 100R; R_0402_1005Metric; MPN 0402WGF1000TCE; LCSC C25076
R21, R22, R23, R24, R25, R26, R27, R28: 0R; R_0402_1005Metric; MPN 0402WGF0000TCE; LCSC C17168
SCREW1, SCREW2, SCREW3, SCREW4: M2; MountingHole_M2_Pad
TP3: EE_WP; TestPoint_Pad_D1.0mm
TP21: USR_P7; TestPoint_Pad_D1.0mm
TP22: USR_P8; TestPoint_Pad_D1.0mm
TP23: USR_P9; TestPoint_Pad_D1.0mm
TP24: USR_P10; TestPoint_Pad_D1.0mm
TP25: USR_P25; TestPoint_Pad_D1.0mm
TP26: USR_P27; TestPoint_Pad_D1.0mm
TP27: USR_P28; TestPoint_Pad_D1.0mm
TP28: USR_P29; TestPoint_Pad_D1.0mm
U1: AT24C02C-XHM-T; TSSOP-8_4.4x3mm_P0.65mm; MPN AT24C02C-XHM-T; LCSC C48914
U4: TPS259533DSGR; Texas_DSG0008A_WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; MPN TPS259533DSGR; LCSC C2155777

Connections:
3V3: C13.1, H1.3, H1.4, R11.1, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.8 (VCC)
5V_PROT: R5.1, U4.5 (OUT)
5V_USER: C6.1, C7.1, C8.1, R5.2
+5V: C1.1, C2.1, C3.1, C4.1, C12.1, D2.1 (A1), H1.1, H1.2, U4.3 (IN), U4.4 (IN)
ESP_INT: H1.13, R7.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C12.2, C13.2, D2.2 (A2), H1.5, H1.6, H1.11, H1.12, H1.17, H1.18, H1.23, H1.24, H1.30, R2.2, R3.2, SCREW1.1, SCREW2.1, SCREW3.1, SCREW4.1, U1.4 (GND), U4.8 (GND), U4.9 (EP)
ID_SCL: H1.14, R14.1
ID_SDA: H1.15, R15.1
MUX_P7: H1.7, R21.1
MUX_P8: H1.8, R22.1
MUX_P9: H1.9, R23.1
MUX_P10: H1.10, R24.1
MUX_P25: H1.25, R25.1
MUX_P27: H1.27, R26.1
MUX_P28: H1.28, R27.1
MUX_P29: H1.29, R28.1
unnamed: R14.2, U1.6 (SCL)
unnamed: R15.2, U1.5 (SDA)
unnamed: R11.2, TP3.1, U1.7 (WP)
unnamed: R2.1, U4.2 (EN/OVLO)
unnamed: R7.1, U4.6 (FLT)
unnamed: R3.1, U4.7 (ILM)
unnamed: C5.1, U4.1 (dVdt)
USR_P7: R21.2, TP21.1
USR_P8: R22.2, TP22.1
USR_P9: R23.2, TP23.1
USR_P10: R24.2, TP24.1
USR_P25: R25.2, TP25.1
USR_P27: R26.2, TP26.1
USR_P28: R27.2, TP27.1
USR_P29: R28.2, TP28.1

Notes on the sheet:
30-Pin header (bottom) / 30-Pin 排针（底面）
Pad numbers per spec; 16/19/20/21/22/26 open / 背包焊盘号；16、19、20、21、22、26 默认悬空
5V input protection / 5V 入口保护
eFuse I_LIM = 2000/R3 + 0.04 = 2.04 A; FLT (active low) to ESP_INT via R7 / 电子保险丝限流 2.04 A，FLT 经 R7 到 ESP_INT
Protected 5V for your circuit / 受保护 5V 输出
Take power from 5V_USER (inner PWR plane); 5V total <= 2 A / 用户电路从 5V_USER（内层 PWR 平面）取电，5V 合计 ≤ 2 A
ID card 0x57 (programmed) / 身份卡 0x57 烧录版
DIY must program the descriptor (product_id 0xF000-0xFFFE); pull TP3 low to write / DIY 必须烧写描述符，写入时 TP3 拉低
Reuse-area 0R series resistors / 复用区 0 Ω 串阻
Near the header; USR_P* go to your circuit / 靠近排针；USR_P* 接你的电路
Mounting holes / 安装孔
M2, to GND / M2，接 GND

Board: 4 copper layers, 83.0 x 40.0 mm, 42 parts (7 on the bottom side), 31 nets.
